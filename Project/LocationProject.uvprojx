# Keil uVision project LocationProject.uvprojx, settings and files
target LocPro (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LocationProject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\Start;..\User;..\System;..\Driver\BSP;..\Driver\HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Start/: startup_stm32f103xb.s
  group Driver/Hal_Driver
    ../Driver/HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_i2c.c
  group Driver/BSP
    ../Driver/BSP/usart/: usart.c
    ../Driver/BSP/gpio/: gpio.c
  group System
    ../System/Sys/: sys.c
    ../System/Delay/: delay.c
    ../System/Debug/: debug.c
  group User
    ../User/: main.c stm32f1xx_it.c user_config.h
    ../Start/: system_stm32f1xx.c
